# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: output +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32H743xx,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../SYSTEM;../BSP;../Application;../Modules;../BSP/GPIO;../BSP/TIMER;../BSP/FMC;../BSP/DMA;../BSP/USART;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\BSP\USB;..\Application\USB;..\Bootloader
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\Project.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: fmc.c main.c gpio.c freertos.c memorymap.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_dma.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Bootloader
    ../Bootloader/: boot_crc32.c boot_protocol.c boot_upgrade.c boot_image_info.c boot_app.c boot_service.c
  group BSP
    ../BSP/GPIO/: bsp_gpio.c
    ../BSP/: bsp.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/FMC/: bsp_fmc.c
    ../BSP/DMA/: bsp_dma.c
    ../BSP/USART/: bsp_usart.c bsp_boot_usart.c
  group Modules
    ../Modules/: Module_Key.c Module_Key.h Module.c Module.h Module_AD7616.c Module_AD7616.h Module_Serial411.c Module_Serial411.h Module_LightCounting.c Module_LightCounting.h Module_ReceiveUpper.c Module_ReceiveUpper.h Module_TransmitUpper.c Module_TransmitUpper.h
  group App
    ../Application/: App.c App.h App_TasksInit.c App_TasksInit.h App_WaveCollectionTask.c App_WaveCollectionTask.h App_VOFA_DataUpload.c App_VOFA_DataUpload.h App_IncentiveSettingsTask.c App_IncentiveSettingsTask.h App_LightCollectionTask.c App_LightCollectionTask.h App_CurveFit.c App_CurveFit.h
  group SYSTEM
    ../SYSTEM/: sys.c sys.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/USB_DEVICE/App
    ../Application/USB/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../BSP/USB/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
